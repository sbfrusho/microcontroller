# Keil uVision project ledBlink.uvproj, settings and files
target Target 1 (MCS-51)
  device: uPSD3212C STMicroelectronics
  cpu: IRAM(0-0xFF) CLOCK(40000000)
  output: ledBlink
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTU32.A51
